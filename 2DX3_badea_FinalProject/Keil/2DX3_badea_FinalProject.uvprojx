# Keil uVision project 2DX3_badea_FinalProject.uvprojx, settings and files
target 2DX3 Final Project (badea) (6190000::V6.19::ARMCLANG)
  device: MSP432E401Y Texas Instruments
  pack: TexasInstruments.MSP432E4_DFP.3.2.6
  cpu: IRAM(0x20000000,0x00040000) IROM(0x00000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: 2DX3 Final Project
  c flags: Optim=2 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=5 wLevel=3
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x40000
  group Source Group 1
    ./: PLL.c SysTick.c vl53l1_platform_2dx4.c VL53L1X_api.c onboardLEDs.c uart.c 2DX3_badea_FinalProject.c
software components: CMSIS:CORE 5.6.0, Device:Startup 3.2.3
